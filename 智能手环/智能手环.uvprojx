# Keil uVision project 智能手环.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 智能手环 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user;.\api;.\STM32F4xx_StdPeriph_Driver\inc;.\hp_6
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./startup/: startup_stm32f411xe.s
  group user
    ./user/: stm32f4xx_it.c system_stm32f4xx.c main.c sys.c
  group api
    ./api/: delay.c led.c oled.c font_16x16.c sht20.c usart.c rtc.c mpu6050.c
  group hp_6
    ./hp_6/: hp6.c iic.c
software components: CMSIS:CORE 5.1.1
